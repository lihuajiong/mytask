# Keil uVision project myproject.uvprojx, settings and files
target MyProject (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: myproject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Core\CMSIS\startup;..\Core\CMSIS;..\RTX\INC;..\RTX\LIB\ARM;..\RTX\SRC;..\RTX\Templates;..\User;..\Stdlib;..\Task;..\Bsp;..\Stdlib\FWlib\inc;..\Tool
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c
  group Core
    ../Core/CMSIS/startup/: startup_stm32f10x_hd.s
    ../Core/CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group RTX
    ../RTX/Templates/: RTX_Conf_CM.c
    ../RTX/LIB/ARM/: RTX_CM3.lib
  group Stdlib
    ../Stdlib/FWlib/: core_cm3.c
    ../Stdlib/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Bsp
    ../Bsp/: bsp_led.c bsp_usart.c bsp_can.c
  group Tool
    ../Tool/: Tool_PID.c
